Properties of the parts of a building model (IFC4)

# File
Description: Industrie-Einbau-Kanaltemperaturfühler, PT 1000, Einbaulänge 65 mm, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: G9150020, Industrie-Einbau-Kanaltemperaturfühler, PT 1000, Einbaulänge 65 mm
In: Raum
Description: Der Industrie-Einbaukanalfühler IKF1 wird zur Messung der Temperaturen von Flüssigkeiten und Gasen in Rohrleitungen, Luftkanälen oder Behältern im Maschinen-, Apparate- und Anlagenbau eingesetzt. Zum Einsatz in Luftkanälen wird der Montageflansch (MF) benötigt. Bei Verwendung in Flüssigkeiten sind Tauchhülsen aus Messing vernickelt (THMs) einzusetzen. Für aggressive Medien werden Tauchhülsen aus Edelstahl V4A (THV) empfohlen. Tauchhülsen oder Montageflansch gehören nicht zum Lieferumfang und müssen als Zubehör separat bestellt werden.; Classification: EC004240 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: G9150020; ModelLabel: IKF1P1000/50; GlobalTradeItemNumber: 4050528041180; ProductURL: https://alre.de/produkt_G9150020
Pset_Specification - NominalLength: 0.126 m; NominalWidth: 0.082 m; NominalDepth: 0.07 m; NetWeight: 0.252
Pset_ALRE_ETIM_Properties - Mit Gehäuse: yes; Art der Spannungsversorgung: ohne; Umgebungstemperatur: -30; Ausführung des elektrischen Anschlusses: Schraubanschluss; Deckelbefestigung: geschraubt; Explosionsgeschützt: no; Schutzart (IP): IP43; Mit Befestigungsmaterial: no; Einsatzgebiet: Tauchrohr/-kanal; Geeignet für Flüssigkeiten: yes; Geeignet für Gase: yes; Temperaturmessbereich: -30; Sensorelement innerhalb des Gehäuses: no; Aktive Temperaturmessung: no; Passive Temperaturmessung: yes; Max. Umgebungsfeuchtigkeit (nicht kondensierend): 95; Sensorelement außerhalb des Gehäuses: yes; Durchmesser Sensorelement: 6; Einstecklänge: 65; Gehäusehöhe: 126; Gehäusebreite: 82; Gehäusetiefe: 70; Festes Kabel am Sensor: no; Geeignet für Luft: yes; ETIM-Klasse: EC004240; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-G9150020.pdf
